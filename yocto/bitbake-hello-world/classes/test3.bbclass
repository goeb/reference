
python() {
    bb.warn("in test3.bbclass: A=%s" % d.getVar('A'))
}
