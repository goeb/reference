addtask build
require local.conf

