
python() {
    bb.warn("in test2.bbclass: A=%s" % d.getVar('A'))
}
