
python() {
    bb.warn("in test1.bbclass: A=%s" % d.getVar('A'))
}
